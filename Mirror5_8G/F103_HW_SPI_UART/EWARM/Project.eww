<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F103_HW_SPI_UART.ewp</path>
  </project>
  <batchBuild />
</workspace>
