<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MT_SSD1306_Example_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
